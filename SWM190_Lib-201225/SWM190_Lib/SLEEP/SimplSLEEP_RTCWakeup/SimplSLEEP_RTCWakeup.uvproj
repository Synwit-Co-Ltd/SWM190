# Keil uVision project SimplSLEEP_RTCWakeup.uvproj, settings and files
target SWM190 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SimplSLEEP_RTCWakeup
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2
  c include: ..\..\SWM190_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM190_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM190_StdPeriph_Driver\CSL\SWM190_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ../../SWM190_StdPeriph_Driver/CSL/SWM190_StdPeriph_Driver/: SWM190_adc.c SWM190_exti.c SWM190_gpio.c SWM190_i2c.c SWM190_pwm.c SWM190_timr.c SWM190_uart.c SWM190_wdt.c SWM190_dma.c SWM190_flash.c SWM190_port.c SWM190_spi.c SWM190_rtc.c SWM190_cache.c SWM190_cordic.c SWM190_div.c SWM190_sleep.c
  group CSL\CMSIS
    ../../SWM190_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM190.c
    ../../SWM190_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM190.s
