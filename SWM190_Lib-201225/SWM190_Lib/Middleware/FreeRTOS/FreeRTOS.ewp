# IAR project FreeRTOS.ewp, settings and files
configuration SWM190 (ARM, debug)
  General.OGChipSelectEditMenu: SWM190xB Synwit SWM190xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\SWM190_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM190_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM190_StdPeriph_Driver\CSL\SWM190_StdPeriph_Driver; .\APP\FreeRTOS; .\APP\FreeRTOS\port_IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: APP/FreeRTOS
  OBJCOPY.OOCOutputFile: SWM2400_StdPeriph_Driver.srec
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CSL_StdPD
    ../../SWM190_StdPeriph_Driver/CSL/SWM190_StdPeriph_Driver/: SWM190_rtc.c SWM190_i2c.c SWM190_adc.c SWM190_timr.c SWM190_gpio.c SWM190_wdt.c SWM190_exti.c SWM190_flash.c SWM190_dma.c SWM190_pwm.c SWM190_port.c SWM190_spi.c SWM190_uart.c
  group CSL_CMSIS
    ../../SWM190_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM190.s
    ../../SWM190_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM190.c
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: tasks.c queue.c list.c
    ./APP/FreeRTOS/port_IAR/: port.c portasm.s
    ./APP/FreeRTOS/heap/: heap_1.c
